# IAR project ch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303VC ST STM32F303VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TEST_CFG_SIZE_REPORT=0; CORTEX_USE_FPU=1
  ICCARM.CCIncludePath2: ..\; ..\cfg; ..\..\..\..\os\license; ..\..\..\..\os\common\startup\ARMCMx\devices\STM32F3xx; ..\..\..\..\os\common\ext\ARM\CMSIS\Core\Include; ..\..\..\..\os\common\ext\ST\STM32F3xx; ..\..\..\..\os\common\portability\IAR; ..\..\..\..\os\common\ports\ARM-common; ..\..\..\..\os\common\ports\ARMv7-M; ..\..\..\..\os\common\oslib\include; ..\..\..\..\os\rt\include; ..\..\..\..\os\oslib\include; ..\..\..\..\os\hal\osal\rt-nil; ..\..\..\..\os\hal\include; ..\..\..\..\os\hal\boards\ST_STM32F3_DISCOVERY; ..\..\..\..\os\hal\ports\common\ARMCMx; ..\..\..\..\os\hal\ports\STM32\STM32F3xx; ..\..\..\..\os\hal\ports\STM32\LLD\ADCv3; ..\..\..\..\os\hal\ports\STM32\LLD\CANv1; ..\..\..\..\os\hal\ports\STM32\LLD\DMAv1; ..\..\..\..\os\hal\ports\STM32\LLD\EXTIv1; ..\..\..\..\os\hal\ports\STM32\LLD\GPIOv2; ..\..\..\..\os\hal\ports\STM32\LLD\I2Cv2; ..\..\..\..\os\hal\ports\STM32\LLD\RTCv2; ..\..\..\..\os\hal\ports\STM32\LLD\SPIv2; ..\..\..\..\os\hal\ports\STM32\LLD\SYSTICKv1; ..\..\..\..\os\hal\ports\STM32\LLD\TIMv1; ..\..\..\..\os\hal\ports\STM32\LLD\USARTv2; ..\..\..\..\os\hal\ports\STM32\LLD\USBv1; ..\..\..\..\os\hal\ports\STM32\LLD\xWDGv1; ..\..\..\..\os\test\include; ..\..\..\..\test\rt\source\test; ..\..\..\..\test\oslib\source\test
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: TEST_CFG_SIZE_REPORT=0; CORTEX_USE_FPU=1
  AARM.AUserIncludes: ..; ..\cfg; ..\..\..\..\os\license; ..\..\..\..\os\common\startup\ARMCMx\devices\STM32F3xx; ..\..\..\..\os\common\ports\ARMv7-M; ..\..\..\..\os\hal\boards\ST_STM32F3_DISCOVERY
  OBJCOPY.OOCOutputFile: ch.srec
  ILINK.IlinkOutputFile: ch.out
  ILINK.IlinkIcfFile: ch.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\; ..\cfg; ..\..\..\..\os\license; ..\..\..\..\os\common\startup\ARMCMx\devices\STM32F3xx; ..\..\..\..\os\common\ext\ARM\CMSIS\Core\Include; ..\..\..\..\os\common\ext\ST\STM32F3xx; ..\..\..\..\os\common\portability\IAR; ..\..\..\..\os\common\ports\ARM-common; ..\..\..\..\os\common\ports\ARMv7-M; ..\..\..\..\os\common\oslib\include; ..\..\..\..\os\rt\include; ..\..\..\..\os\oslib\include; ..\..\..\..\os\hal\osal\rt-nil; ..\..\..\..\os\hal\include; ..\..\..\..\os\hal\boards\ST_STM32F3_DISCOVERY; ..\..\..\..\os\hal\ports\common\ARMCMx; ..\..\..\..\os\hal\ports\STM32\STM32F3xx; ..\..\..\..\os\hal\ports\STM32\LLD\ADCv3; ..\..\..\..\os\hal\ports\STM32\LLD\CANv1; ..\..\..\..\os\hal\ports\STM32\LLD\DMAv1; ..\..\..\..\os\hal\ports\STM32\LLD\EXTIv1; ..\..\..\..\os\hal\ports\STM32\LLD\GPIOv2; ..\..\..\..\os\hal\ports\STM32\LLD\I2Cv2; ..\..\..\..\os\hal\ports\STM32\LLD\RTCv2; ..\..\..\..\os\hal\ports\STM32\LLD\SPIv2; ..\..\..\..\os\hal\ports\STM32\LLD\SYSTICKv1; ..\..\..\..\os\hal\ports\STM32\LLD\TIMv1; ..\..\..\..\os\hal\ports\STM32\LLD\USARTv2; ..\..\..\..\os\hal\ports\STM32\LLD\USBv1; ..\..\..\..\os\hal\ports\STM32\LLD\xWDGv1; ..\..\..\..\os\test\include; ..\..\..\..\test\rt\source\test; ..\..\..\..\test\oslib\source\test; ..\
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group cfg
    ../cfg/: chconf.h halconf.h mcuconf.h
  group os/common/oslib/include
    ../../../../os/oslib/include/: chbsem.h chdelegates.h chfactory.h chjobs.h chlib.h chmboxes.h chmemcore.h chmemheaps.h chmempools.h chobjcaches.h chobjfifos.h chpipes.h
  group os/common/oslib/src
    ../../../../os/oslib/src/: chdelegates.c chfactory.c chmboxes.c chmemcore.c chmemheaps.c chmempools.c chobjcaches.c chpipes.c
  group os/common/port
    ../../../../os/common/ports/ARMv7-M/: chcore.c chcore.h
    ../../../../os/common/ports/ARMv7-M/compilers/IAR/: chcoreasm.s
  group os/common/startup
    ../../../../os/common/startup/ARMCMx/devices/STM32F3xx/: cmparams.h
    ../../../../os/common/startup/ARMCMx/compilers/IAR/: cstartup.s vectors.s
  group os/hal/board
    ../../../../os/hal/boards/ST_STM32F3_DISCOVERY/: board.c board.h
  group os/hal/include
    ../../../../os/hal/include/: hal.h hal_adc.h hal_buffers.h hal_can.h hal_channels.h hal_crypto.h hal_dac.h hal_efl.h hal_files.h hal_flash.h hal_gpt.h hal_i2c.h hal_i2s.h hal_icu.h hal_ioblock.h hal_mac.h hal_mii.h hal_mmc_spi.h hal_mmcsd.h hal_objects.h hal_pal.h hal_persistent.h hal_pwm.h hal_queues.h hal_rtc.h hal_sdc.h hal_serial.h hal_serial_usb.h hal_sio.h hal_spi.h hal_st.h hal_streams.h hal_trng.h hal_uart.h hal_usb.h hal_usb_cdc.h hal_wdg.h hal_wspi.h
  group os/hal/lib/streams
    ../../../../os/hal/lib/streams/: chprintf.c chprintf.h memstreams.c memstreams.h
  group os/hal/port
    ../../../../os/hal/ports/STM32/LLD/ADCv3/: hal_adc_lld.c hal_adc_lld.h
    ../../../../os/hal/ports/STM32/LLD/CANv1/: hal_can_lld.c hal_can_lld.h
    ../../../../os/hal/ports/STM32/LLD/DACv1/: hal_dac_lld.c hal_dac_lld.h
    ../../../../os/hal/ports/STM32/LLD/TIMv1/: hal_gpt_lld.c hal_gpt_lld.h hal_icu_lld.c hal_icu_lld.h hal_pwm_lld.c hal_pwm_lld.h stm32_tim.h
    ../../../../os/hal/ports/STM32/LLD/I2Cv2/: hal_i2c_lld.c hal_i2c_lld.h
    ../../../../os/hal/ports/STM32/LLD/SPIv2/: hal_i2s_lld.c hal_i2s_lld.h hal_spi_lld.c hal_spi_lld.h
    ../../../../os/hal/ports/STM32/STM32F3xx/: hal_lld.c hal_lld.h stm32_isr.c stm32_isr.h stm32_rcc.h stm32_registry.h
    ../../../../os/hal/ports/STM32/LLD/GPIOv2/: hal_pal_lld.c hal_pal_lld.h
    ../../../../os/hal/ports/STM32/LLD/RTCv2/: hal_rtc_lld.c hal_rtc_lld.h
    ../../../../os/hal/ports/STM32/LLD/SDMMCv1/: hal_sdc_lld.c hal_sdc_lld.h
    ../../../../os/hal/ports/STM32/LLD/USARTv2/: hal_serial_lld.c hal_serial_lld.h hal_uart_lld.c hal_uart_lld.h
    ../../../../os/hal/ports/STM32/LLD/SYSTICKv1/: hal_st_lld.c hal_st_lld.h
    ../../../../os/hal/ports/STM32/LLD/USBv1/: hal_usb_lld.c hal_usb_lld.h stm32_usb.h
    ../../../../os/hal/ports/STM32/LLD/xWDGv1/: hal_wdg_lld.c hal_wdg_lld.h
    ../../../../os/hal/ports/common/ARMCMx/: nvic.c nvic.h
    ../../../../os/hal/ports/STM32/LLD/DMAv1/: stm32_dma.c stm32_dma.h
    ../../../../os/hal/ports/STM32/LLD/EXTIv1/: stm32_exti.c stm32_exti.h
  group os/hal/src
    ../../../../os/hal/src/: hal.c hal_adc.c hal_buffers.c hal_can.c hal_crypto.c hal_dac.c hal_efl.c hal_flash.c hal_gpt.c hal_i2c.c hal_i2s.c hal_icu.c hal_mac.c hal_mmc_spi.c hal_mmcsd.c hal_pal.c hal_pwm.c hal_queues.c hal_rtc.c hal_sdc.c hal_serial.c hal_serial_usb.c hal_sio.c hal_spi.c hal_st.c hal_trng.c hal_uart.c hal_usb.c hal_wdg.c hal_wspi.c
  group os/rt/include
    ../../../../os/rt/include/: ch.h chalign.h chchecks.h chcond.h chcustomer.h chdebug.h chdynamic.h chevents.h chinstances.h chmsg.h chmtx.h chregistry.h chrfcu.h chschd.h chsem.h chstats.h chsys.h chsystypes.h chthreads.h chtm.h chtrace.h chvt.h
  group os/rt/src
    ../../../../os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chinstances.c chmsg.c chmtx.c chregistry.c chrfcu.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chtrace.c chvt.c
  group test/lib
    ../../../../os/test/src/: ch_test.c ch_test_printf.c
    ../../../../os/test/include/: ch_test.h
  group test/source/oslib
    ../../../../test/oslib/source/test/: oslib_test_root.c oslib_test_root.h oslib_test_sequence_001.c oslib_test_sequence_001.h oslib_test_sequence_002.c oslib_test_sequence_002.h oslib_test_sequence_003.c oslib_test_sequence_003.h oslib_test_sequence_004.c oslib_test_sequence_004.h oslib_test_sequence_005.c oslib_test_sequence_005.h oslib_test_sequence_006.c oslib_test_sequence_006.h oslib_test_sequence_007.c oslib_test_sequence_007.h oslib_test_sequence_008.c oslib_test_sequence_008.h oslib_test_sequence_009.c oslib_test_sequence_009.h oslib_test_sequence_010.c oslib_test_sequence_010.h oslib_test_sequence_011.c oslib_test_sequence_011.h
  group test/source/rt
    ../../../../test/rt/source/test/: rt_test_root.c rt_test_root.h rt_test_sequence_001.c rt_test_sequence_001.h rt_test_sequence_002.c rt_test_sequence_002.h rt_test_sequence_003.c rt_test_sequence_003.h rt_test_sequence_004.c rt_test_sequence_004.h rt_test_sequence_005.c rt_test_sequence_005.h rt_test_sequence_006.c rt_test_sequence_006.h rt_test_sequence_007.c rt_test_sequence_007.h rt_test_sequence_008.c rt_test_sequence_008.h rt_test_sequence_009.c rt_test_sequence_009.h rt_test_sequence_010.c rt_test_sequence_010.h rt_test_sequence_011.c rt_test_sequence_011.h rt_test_sequence_012.c rt_test_sequence_012.h
