# Keil uVision project ch.uvprojx, settings and files
target Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) IRAM2(0x10000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(72000000) ELITTLE
  output: ch +hex
  c flags: Optim=3 uC99=1 wLevel=2
  c define: CORTEX_USE_FPU=0 TEST_CFG_SIZE_REPORT=0 __heap_base__=Image$$$$RW_IRAM1$$$$ZI$$$$Limit __heap_end__=Image$$$$RW_IRAM2$$$$Base
  c misc: -USTM32F303xC
  c include: ..\;..\cfg;..\..\..\..\os\license;..\..\..\..\os\common\startup\ARMCMx\devices\STM32F3xx;..\..\..\..\os\common\ext\ARM\CMSIS\Core\Include;..\..\..\..\os\common\ext\ST\STM32F3xx;..\..\..\..\os\common\portability\Keil;..\..\..\..\os\common\ports\ARM-common;..\..\..\..\os\common\ports\ARMv7-M;..\..\..\..\os\rt\include;..\..\..\..\os\oslib\include;..\..\..\..\os\hal\osal\rt-nil;..\..\..\..\os\hal\include;..\..\..\..\os\hal\boards\ST_STM32F3_DISCOVERY;..\..\..\..\os\hal\ports\common\ARMCMx;..\..\..\..\os\hal\ports\STM32\STM32F3xx;..\..\..\..\os\hal\ports\STM32\LLD\ADCv3;..\..\..\..\os\hal\ports\STM32\LLD\CANv1;..\..\..\..\os\hal\ports\STM32\LLD\DACv1;..\..\..\..\os\hal\ports\STM32\LLD\DMAv1;..\..\..\..\os\hal\ports\STM32\LLD\EXTIv1;..\..\..\..\os\hal\ports\STM32\LLD\GPIOv2;..\..\..\..\os\hal\ports\STM32\LLD\I2Cv2;..\..\..\..\os\hal\ports\STM32\LLD\RTCv2;..\..\..\..\os\hal\ports\STM32\LLD\SPIv2;..\..\..\..\os\hal\ports\STM32\LLD\SYSTICKv1;..\..\..\..\os\hal\ports\STM32\LLD\TIMv1;..\..\..\..\os\hal\ports\STM32\LLD\USART;..\..\..\..\os\hal\ports\STM32\LLD\USARTv2;..\..\..\..\os\hal\ports\STM32\LLD\USBv1;..\..\..\..\os\hal\ports\STM32\LLD\xWDGv1;..\..\..\..\os\test\include;..\..\..\..\test\rt\source\test;..\..\..\..\test\oslib\source\test
  asm misc: --cpreproc --cpreproc_opts=-DCORTEX_USE_FPU=0
  asm include: ..\;..\cfg;..\..\..\..\os\license;..\..\..\..\os\common\startup\ARMCMx\devices\STM32F3xx;..\..\..\..\os\common\ports\ARMv7-M;..\..\..\..\os\hal\boards\ST_STM32F3_DISCOVERY
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT6: RAM 0x10000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x2000a000 size 0x1
  group license
    ../../../../os/license/: chcustomer.h chlicense.h chversion.h
  group startup
    ../../../../os/common/startup/ARMCMx/compilers/RVCT/: cstartup.s vectors.s
    ../../../../os/common/startup/ARMCMx/devices/STM32F3xx/: cmparams.h
  group cmsis
    ../../../../os/common/ext/ARM/CMSIS/Core/Include/: core_cm4.h
    ../../../../os/common/ext/ST/STM32F3xx/: stm32f3xx.h
  group kernel port
    ../../../../os/common/ports/ARMv7-M/: chcore.c chcore.h mpu.h
    ../../../../os/common/ports/ARMv7-M/compilers/RVCT/: chcoreasm.s
  group kernel
    ../../../../os/rt/include/: chalign.h ch.h chcond.h chdebug.h chdynamic.h chevents.h chmsg.h chmtx.h chregistry.h chschd.h chsem.h chstats.h chsys.h chthreads.h chtm.h chvt.h chchecks.h chtrace.h chrestrictions.h chtime.h chearly.h chinstances.h chlists.h chobjects.h chport.h chrfcu.h
    ../../../../os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chmsg.c chmtx.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chvt.c chrfcu.c chinstances.c chtrace.c
  group oslib
    ../../../../os/oslib/include/: chbsem.h chdelegates.h chfactory.h chjobs.h chlib.h chmboxes.h chmemcore.h chmemheaps.h chmempools.h chobjcaches.h chobjfifos.h chpipes.h chmemchecks.h
    ../../../../os/oslib/src/: chdelegates.c chfactory.c chmboxes.c chmemcore.c chmemheaps.c chmempools.c chobjcaches.c chpipes.c chmemchecks.c
  group osal
    ../../../../os/hal/osal/rt-nil/: osal.c osal.h
  group hal
    ../../../../os/hal/include/: hal.h hal_adc.h hal_buffers.h hal_can.h hal_channels.h hal_dac.h hal_files.h hal_gpt.h hal_i2c.h hal_i2s.h hal_icu.h hal_ioblock.h hal_mac.h hal_mii.h hal_mmc_spi.h hal_mmcsd.h hal_pal.h hal_pwm.h hal_queues.h hal_rtc.h hal_sdc.h hal_serial.h hal_serial_usb.h hal_spi.h hal_st.h hal_streams.h hal_uart.h hal_usb.h hal_usb_cdc.h hal_wdg.h hal_crypto.h hal_efl.h hal_flash.h hal_objects.h hal_persistent.h hal_sio.h hal_trng.h hal_wspi.h
    ../../../../os/hal/src/: hal.c hal_adc.c hal_buffers.c hal_can.c hal_dac.c hal_gpt.c hal_i2c.c hal_i2s.c hal_icu.c hal_mac.c hal_mmc_spi.c hal_mmcsd.c hal_pal.c hal_pwm.c hal_queues.c hal_rtc.c hal_sdc.c hal_serial.c hal_serial_usb.c hal_spi.c hal_st.c hal_uart.c hal_usb.c hal_wdg.c hal_crypto.c hal_efl.c hal_flash.c hal_sio.c hal_trng.c hal_wspi.c
  group hal_port
    ../../../../os/hal/ports/STM32/LLD/ADCv3/: hal_adc_lld.c
    ../../../../os/hal/ports/STM32/LLD/CANv1/: hal_can_lld.c
    ../../../../os/hal/ports/STM32/LLD/DACv1/: hal_dac_lld.c
    ../../../../os/hal/ports/STM32/LLD/DMAv1/: stm32_dma.c
    ../../../../os/hal/ports/STM32/LLD/EXTIv1/: stm32_exti.c
    ../../../../os/hal/ports/STM32/LLD/GPIOv2/: hal_pal_lld.c
    ../../../../os/hal/ports/STM32/LLD/I2Cv2/: hal_i2c_lld.c
    ../../../../os/hal/ports/STM32/LLD/USARTv2/: hal_serial_lld.c hal_uart_lld.c
    ../../../../os/hal/ports/STM32/LLD/RTCv2/: hal_rtc_lld.c
    ../../../../os/hal/ports/STM32/LLD/SPIv2/: hal_i2s_lld.c hal_spi_lld.c
    ../../../../os/hal/ports/STM32/LLD/TIMv1/: hal_gpt_lld.c hal_icu_lld.c hal_pwm_lld.c
    ../../../../os/hal/ports/STM32/LLD/USBv1/: hal_usb_lld.c
    ../../../../os/hal/ports/STM32/LLD/xWDGv1/: hal_wdg_lld.c
    ../../../../os/hal/ports/STM32/STM32F3xx/: hal_lld.c stm32_isr.c
    ../../../../os/hal/ports/STM32/LLD/SYSTICKv1/: hal_st_lld.c
    ../../../../os/hal/ports/common/ARMCMx/: nvic.c
  group board
    ../../../../os/hal/boards/ST_STM32F3_DISCOVERY/: board.c board.h
  group test
    ../../../../test/rt/source/test/: rt_test_root.c rt_test_sequence_001.c rt_test_sequence_002.c rt_test_sequence_003.c rt_test_sequence_004.c rt_test_sequence_005.c rt_test_sequence_006.c rt_test_sequence_007.c rt_test_sequence_008.c rt_test_sequence_009.c rt_test_sequence_010.c rt_test_sequence_011.c rt_test_sequence_012.c
    ../../../../test/oslib/source/test/: oslib_test_root.c oslib_test_sequence_001.c oslib_test_sequence_002.c oslib_test_sequence_003.c oslib_test_sequence_004.c oslib_test_sequence_005.c oslib_test_sequence_006.c oslib_test_sequence_007.c oslib_test_sequence_008.c oslib_test_sequence_009.c oslib_test_sequence_010.c oslib_test_sequence_011.c
    ../../../../os/test/src/: ch_test.c ch_test_printf.c
  group demo
    ../: main.c
    ../cfg/: chconf.h halconf.h mcuconf.h
